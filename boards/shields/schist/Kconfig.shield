## config/boards/shields/schist01/Kconfig.defconfig
```kconfig
if SHIELD_SCHIST01

config ZMK_KEYBOARD_NAME
    default "schist01"
CONFIG_CIRQUE_TRACKPAD=y
CONFIG_CIRQUE_TRACKPAD_SPI=y
endif
```
